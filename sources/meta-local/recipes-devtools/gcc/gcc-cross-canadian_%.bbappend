require conf/kp/standalone-tc.conf