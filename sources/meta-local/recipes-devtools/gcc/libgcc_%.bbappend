require conf/kp/standalone-tc.conf

NANO_OPTIONS_remove = "-fdata-sections -ffunction-sections"