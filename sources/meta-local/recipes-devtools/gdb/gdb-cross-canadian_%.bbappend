RDEPENDS_${PN}_append_sdkmingw32 = " nativesdk-libgcc "